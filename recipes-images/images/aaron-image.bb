
require systemd-image.bb

export IMAGE_BASENAME = "aaron-image"
